# Keil uVision project atk_f407.uvprojx, settings and files
target ATK-MS901M (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: .\Drivers;.\User;.\Drivers\SYSTEM;.\Drivers\SYSTEM\sys;.\Drivers\SYSTEM\delay;.\Drivers\SYSTEM\usart;.\Drivers\SYSTEM\usart2;.\Drivers\CMSIS;.\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Drivers\CMSIS\Include;.\Drivers\STM32F4xx_HAL_Driver;.\Drivers\STM32F4xx_HAL_Driver\Inc;.\Drivers\BSP;.\Drivers\BSP\ATK_MS901M;.\Drivers\BSP\ADC;.\Drivers\BSP\GPIO;.\Drivers\BSP\PWM;.\Drivers\BSP\Calib;.\Drivers\BSP\Kalman;.\Drivers\BSP\Modbus;.\Drivers\BSP\Modbus
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group User
    ./User/: demo.c main.c stm32f4xx_it.c
  group Drivers/SYSTEM
    ./Drivers/SYSTEM/delay/: delay.c
    ./Drivers/SYSTEM/usart/: usart.c
    ./Drivers/SYSTEM/sys/: sys.c
  group Drivers/STM32F4xx_HAL_Driver
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group Drivers/BSP
    ./Drivers/BSP/ATK_MS901M/: atk_ms901m.c atk_ms901m_uart.c
    ./Drivers/BSP/ADC/: adc.c
    ./Drivers/BSP/GPIO/: gpio.c
    ./Drivers/BSP/PWM/: pwm.c
    ./Drivers/BSP/Calib/: calib.c
    ./Drivers/BSP/Kalman/: kalman.c kalman_persist.c
    ./Drivers/BSP/Modbus/: modbus.c servo_comp.c device_config.c port.c mb.c mbascii.c mbrtu.c mbcrc.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncfile.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group modbus
    ./Drivers/BSP/Modbus/: mb.c mbascii.c mbcrc.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncfile.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbrtu.c mbutils.c modbus.c port.c
